# Keil uVision project CISA9.uvprojx, settings and files
target CISA9 (ARM-ADS)
  device: GD32F105RG GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BOOT +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\User\inc;..\UserHardwareLib\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\UserSoftwareLib\inc\CIS;..\FATFS\FatFs11;..\USBH\USB_HOST_Driver\inc;..\USBH\USB_MSC\inc;..\USBH\USB_USE\inc;..\USBH\USB_OTG_Driver\inc;..\UserSoftwareLib\currency\USD;..\UserSoftwareLib\currency\INDIA;..\UserSoftwareLib\currency\KENYA;..\UserSoftwareLib\currency\CNY;..\UserSoftwareLib\currency\CURRENCY;..\UserSoftwareLib\A9B(0832);..\UserSoftwareLib\CIS;..\UserSoftwareLib\Common;..\UserSoftwareLib\LCD0832K03;..\UserSoftwareLib\LCD418;..\UserSoftwareLib\JBY_10\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../UserSoftwareLib/JBY_10/src/: delay.C fifo.C flash.c main_70.C motor.c uart.C disp.C user_udisc.c
  group USB_HOST
    ../USBH/USB_HOST_Driver/scr/: usbh_stdreq.c usbh_ioreq.c usbh_hcs.c usbh_core.c
    ../USBH/USB_MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../USBH/USB_OTG_Driver/scr/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USBH_USE
    ../USBH/USB_USE/scr/: user_bsp.c usbh_usr.c usbh_msc_usr.c fatfs_demo.c
  group FATFS
    ../FATFS/FatFs11/: ff.c diskio_msc&sd.c
    ../FATFS/FatFs11/option/: cc932.c
  group STM32_LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../UserHardwareLib/inc/: user_sysconfig.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
